Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T16:00:38
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 16:00:38 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{72166786-50EA-47D6-B3EC-078D807FADE9}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 16:00:35 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 16:00:36 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 16:00:36 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowTerminal: fix_duco_ducotwin 120 (2)
In: Level 1
Type - PredefinedType: GRILLE; Classification: 31.2 (Uniformat); Material: BERSnl_h4_aluminium
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Construction(Type) - WT_V Fix: yes; WT_V Standaard: no
Type - Identity Data(Type) - Assembly Code: 31.2; BERSnl_C_code_ETIM: Overstroomrooster; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 26/02/2016; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V4; BERSnl_C_description: duco_raamventilatie_ducotwin 120_fix; BERSnl_C_revit_versie: 2016; Manufacturer: Duco; Type Name: fix_duco_ducotwin 120; URL: http://www.duco.eu/producten/; WT_I BaseKeynote: 57.10.90.1
Type - Other(Type) - Category: Air Terminals; Family Name: GEO_DucoTwin 120_geleiders
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: fix_duco_ducotwin 120
Constraints - Moves With Nearby Elements: no
Dimensions - Area: 1.05092 m2; Volume: 0.000942281 m3; WT_V Lengte: 1800 mm
Materials and Finishes - BERSnl_C_materiaal: BERSnl_h4_aluminium
Other - Category: Air Terminals; Family: GEO_DucoTwin 120_geleiders: fix_duco_ducotwin 120; Family and Type: GEO_DucoTwin 120_geleiders: fix_duco_ducotwin 120; Type: GEO_DucoTwin 120_geleiders: fix_duco_ducotwin 120; Type Id: GEO_DucoTwin 120_geleiders: fix_duco_ducotwin 120
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/families
Name (GEO_DucoTwin 120_geleiders:fix_duco_ducotwin 120:...) | Mark
209612 | 238
209613 | 239

# IfcFlowTerminal: medio ak - fix - buis 78 - gemotoriseerd_duco_tronictwin 120 (ak), BERSnl_31_AIR_FB_raamventilatie - tronictwin 120 (ak)_duco:medio ak - fix - buis 78 - gemotoriseerd_duco_tronictwin 120 (ak):209610
In: Level 1
Type - PredefinedType: GRILLE; Classification: 31.2 (Uniformat); Material: BERSnl_h4_aluminium, BERSnl_n_plastic_zwart, BERSnl_a_geperforeerd, Linen, White
Type - Constraints(Type) - Default Elevation: 1500 mm; WT_H Sturingsunit_RF: BERSnl_31_AIR_FB_sturingsunit tronicglasmax-twin 120 - SH_duco: rf - 230v_duco; WT_H Sturingsunit_Wired: BERSnl_31_AIR_FB_sturingsunit tronicglasmax-twin 120 - SH_duco: wired - 24v_duco
Type - Construction(Type) - WT_V Buiten rooster_diepte: 69 mm; WT_V Geleiders_type: GEO_DucoTwin 120_geleiders: fix_duco_ducotwin 120
Type - Dimensions(Type) - BERSnl_C_diepte: 247 mm; BERSnl_C_hoogte: 178.5 mm; WT_V Roosterhoogte: 120 mm
Type - Electrical(Type) - BERSnl_E_c01_aantal_polen: 1; BERSnl_E_c01_arbeidsfactor: 1; BERSnl_E_c01_belastingsklasse: HVAC; BERSnl_E_c01_spanning: 24 V; BERSnl_E_c01_vermogen: 0 W
Type - Identity Data(Type) - Assembly Code: 31.2; BERSnl_C_code_artikel: Medio AK/Fix-Buis 78/Gemotoriseerd; BERSnl_C_code_ETIM: Overstroomrooster; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSnl_C_code_gtin: -; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 26/02/2016; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V4; BERSnl_C_description: duco_raamventilatie_tronictwin 120 (ak)_medio ak - fix - buis 78 - gemotoriseerd; BERSnl_C_model: TronicTwin 120 (AK); BERSnl_C_revit_versie: 2016; BERSnl_C_type: -; Manufacturer: Duco; Model: TronicTwin 120 (AK); OmniClass Number: 3A(57.16.11); Type Name: medio ak - fix - buis 78 - gemotoriseerd_duco_tronictwin 120 (ak); URL: http://www.duco.eu/producten/product.cfm?prod=230&pid=3-28&cat=28; WT_I BaseKeynote: 31.2
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_h4_aluminium; WT_V Binnenprofiel_materiaal: BERSnl_h4_aluminium; WT_V Buitenprofiel_materiaal: BERSnl_h4_aluminium; WT_V Eindkappen_materiaal: BERSnl_n_plastic_zwart; WT_V Rooster_materiaal: BERSnl_a_geperforeerd; WT_V Zonwering_materiaal: Linen, White
Type - Mechanical - Flow(Type) - WT_I Ventilatiecapaciteit 10Pa: 0.759265 m3/s; WT_I Ventilatiecapaciteit 2Pa: 0.63174 m3/s
Type - Model Properties(Type) - WT_I Buis 50: no; WT_I Buis 63: no; WT_I Buis 78: yes; WT_I Cap_zonwering op uitvalarm: no; WT_I Geluidsniveauverschil Dne, W_in open stand: 39 dB; WT_I Kleur: F1 - RAL - Bicolor; WT_I Maximale lengte rooster onder garantie: 3400 mm; WT_I Maximale ton/kleplengte onder garantie: 2000 mm; WT_I Raam_MAX diepte: 135 mm; WT_I Waterwerendheid_in gesloten stand: 1250 Pa; WT_I Winddichtheid_in gesloten stand: 450 Pa; WT_I Zonwering_gemotoriseerd: yes; WT_I Zonwering_maximale breedte: 3400 mm; WT_I Zonwering_maximale hoogte: 3000 mm; WT_I Zonwering_oppervlakte: 12 m2
Type - Other(Type) - Category: Air Terminals; Family Name: BERSnl_31_AIR_FB_raamventilatie - tronictwin 120 (ak)_duco; WT_c1 Omschrijving: c1_communication connector; WT_c2 Omschrijving: c2_elektrische connector
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: medio ak - fix - buis 78 - gemotoriseerd_duco_tronictwin 120 (ak)
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1; WT_H Sturingsunit_type: BERSnl_31_AIR_FB_sturingsunit tronicglasmax-twin 120 - SH_duco: rf - 230v_duco
Construction - WT_V Raam_diepte: 80 mm; WT_V Sturingsunit_RF: yes; WT_V Sturingsunit_Wired: no; WT_V Zijgeleider_hoogte: 1800 mm; WT_V Zonwering_opening lengte: 500 mm; WT_V Zonweringdoek_bediening: BERSnl_31_GM_FB_bediening zonweringdoek_duco: buismotor met knopbediening_duco_bediening zonweringdoek
Dimensions - Area: 1.2946 m2; BERSnl_C_lengte: 1000 mm; Volume: 0.0390523 m3
Identity Data - Mark: 236
Mechanical - System Classification: Communication,Power
Mechanical - Flow - BE_M Drukverschil 10Pa: no; BE_M Drukverschil 2Pa: yes; BERSnl_M_debiet: 0.587518 m3/s
Model Properties - WT_I Onder garantie: Ja
Other - Category: Air Terminals; Family: BERSnl_31_AIR_FB_raamventilatie - tronictwin 120 (ak)_duco: medio ak - fix - buis 78 - gemotoriseerd_duco_tronictwin 120 (ak); Family and Type: BERSnl_31_AIR_FB_raamventilatie - tronictwin 120 (ak)_duco: medio ak - fix - buis 78 - gemotoriseerd_duco_tronictwin 120 (ak); Schedule Level: Level: Level 1; Type: BERSnl_31_AIR_FB_raamventilatie - tronictwin 120 (ak)_duco: medio ak - fix - buis 78 - gemotoriseerd_duco_tronictwin 120 (ak); Type Id: BERSnl_31_AIR_FB_raamventilatie - tronictwin 120 (ak)_duco: medio ak - fix - buis 78 - gemotoriseerd_duco_tronictwin 120 (ak)
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
