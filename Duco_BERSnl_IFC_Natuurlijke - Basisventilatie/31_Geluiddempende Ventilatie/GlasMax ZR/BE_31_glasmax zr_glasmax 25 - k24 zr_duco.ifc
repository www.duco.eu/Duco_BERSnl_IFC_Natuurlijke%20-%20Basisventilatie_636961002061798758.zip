Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T15:46:09
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 15:46:09 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{CE7383AF-A648-463C-A66B-9B8FE53211FD}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 15:46:08 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 15:46:09 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 15:46:09 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowTerminal: glasmax 25 - k24 zr_duco_glasmax zr, BERSnl_31_AIR_FB_raamventilatie - glasmax zr_duco:glasmax 25 - k24 zr_duco_glasmax zr:212092
In: Level 1
Type - PredefinedType: GRILLE; Classification: 31.2 (Uniformat); Material: BERSnl_n_plastic_zwart, BERSnl_h4_aluminium, BERSnl_a_geperforeerd
Type - Constraints(Type) - Default Elevation: 1500 mm
Type - Construction(Type) - WT_V Bediening: BERSnl_31_GM_FB_bediening ventilatierooster_duco: geen_duco_bediening ventilatierooster; WT_V Hendel: BERSnl_31_AIR_FB_hendel geluiddempend_duco: klephendel 15 wit_duco_hendel geluiddempend; WT_V Kokerprofiel: BERSnl_31_GM_FB_kokerprofiel_duco: kokerprofiel - 40 x 25 zwart_duco_kokerprofiel
Type - Dimensions(Type) - BERSnl_C_diepte: 149 mm; BERSnl_C_hoogte: 120 mm; WT_V Roosterhoogte: 80 mm
Type - Identity Data(Type) - Assembly Code: 31.2; BERSnl_C_code_artikel: GlasMax 25/K24 ZR; BERSnl_C_code_ETIM: Overstroomrooster; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSnl_C_code_gtin: -; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 26/02/2016; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V4; BERSnl_C_description: duco_raamventilatie_glasmax zr_glasmax 25 - k24 zr; BERSnl_C_model: GlasMax ZR; BERSnl_C_revit_versie: 2016; BERSnl_C_type: -; Manufacturer: Duco; Model: GlasMax ZR; OmniClass Number: 3A(57.16.11); Type Name: glasmax 25 - k24 zr_duco_glasmax zr; URL: http://www.duco.eu/producten/product.cfm?prod=89&pid=3-16&cat=16; WT_I BaseKeynote: 31.2
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_h4_aluminium; WT_V Binnenprofiel_materiaal: BERSnl_h4_aluminium; WT_V Buitenprofiel_materiaal: BERSnl_h4_aluminium; WT_V Eindkappen_materiaal: BERSnl_n_plastic_zwart; WT_V Rooster_materiaal: BERSnl_a_geperforeerd
Type - Mechanical - Flow(Type) - WT_I Ventilatiecapaciteit 10Pa: 1.35765 m3/s; WT_I Ventilatiecapaciteit 2Pa: 1.29978 m3/s
Type - Model Properties(Type) - WT_I Geluidsniveauverschil Dne, W_in open stand: 27 dB; WT_I Glas_MAX diepte: 32 mm; WT_I Glas_MIN diepte: 20 mm; WT_I Glasaftrek: 80 mm; WT_I Kleur: F1 - RAL - Bicolor; WT_I Kleur kopschotten: Wit, Zwart; WT_I Maximale lengte rooster onder garantie: 4000 mm; WT_I Maximale ton/kleplengte onder garantie: 2000 mm; WT_I Octaafbandwaarden in dB_bij 1000 Hz: 26,8; WT_I Octaafbandwaarden in dB_bij 125 Hz: 24,7; WT_I Octaafbandwaarden in dB_bij 2000 Hz: 28; WT_I Octaafbandwaarden in dB_bij 250 Hz: 26,7; WT_I Octaafbandwaarden in dB_bij 500 Hz: 24,9; WT_I Regelbaarheid in functie van het drukverschil: P4; WT_I Splitsing vanaf lengte: 2000 mm; WT_I U-waarde: 1.56; WT_I Waterdichtheid_in gesloten stand: 1050 Pa; WT_I Winddichtheid_in gesloten stand: 600 Pa
Type - Other(Type) - Category: Air Terminals; Family Name: BERSnl_31_AIR_FB_raamventilatie - glasmax zr_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: glasmax 25 - k24 zr_duco_glasmax zr
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V Hendeloverbrenging & Stangclip: BERSnl_31_AIR_FB_hendeloverbrenging & stangclip_duco: geen_duco_hendeloverbrenging & stangclip; WT_V Losse Bochten: BERSnl_31_AIR_FB_losse bocht_duco: geen_duco_losse bocht; WT_V X_maat: 0 mm
Dimensions - Area: 0.28188 m2; BERSnl_C_lengte: 1000 mm; Volume: 0.01288 m3
Identity Data - Mark: 47
Mechanical - Flow - BE_M Drukverschil 10Pa: no; BE_M Drukverschil 2Pa: yes; BERSnl_M_debiet: 1.22179 m3/s
Model Properties - WT_I Onder garantie: Ja; WT_I Splitsing_aantal: 0; WT_I X_maat MAX: 0 mm; WT_I X_maat MIN: 0 mm
Other - Category: Air Terminals; Family: BERSnl_31_AIR_FB_raamventilatie - glasmax zr_duco: glasmax 25 - k24 zr_duco_glasmax zr; Family and Type: BERSnl_31_AIR_FB_raamventilatie - glasmax zr_duco: glasmax 25 - k24 zr_duco_glasmax zr; Schedule Level: Level: Level 1; Type: BERSnl_31_AIR_FB_raamventilatie - glasmax zr_duco: glasmax 25 - k24 zr_duco_glasmax zr; Type Id: BERSnl_31_AIR_FB_raamventilatie - glasmax zr_duco: glasmax 25 - k24 zr_duco_glasmax zr
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco

# IfcFlowTerminal: kokerprofiel - 40 x 25 zwart_duco_kokerprofiel, BERSnl_31_GM_FB_kokerprofiel_duco:kokerprofiel - 40 x 25 zwart_duco_kokerprofiel:212094
In: Level 1
Type - PredefinedType: GRILLE; Classification: 31.2 (Uniformat)
Type - Constraints(Type) - Default Elevation: 0 mm
Type - Dimensions(Type) - WT_V Diepte: 25 mm; WT_V Hoogte: 40 mm
Type - Identity Data(Type) - Assembly Code: 31.2; BERSnl_C_code_artikel: 23189; BERSnl_C_code_ETIM: Overstroomrooster; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 26/02/2016; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V4; BERSnl_C_description: duco_kokerprofiel_kokerprofiel_kokerprofiel - 40 x 25 zwart; BERSnl_C_model: kokerprofiel; BERSnl_C_revit_versie: 2016; Description: duco_kokerprofiel_40 x 25 zwart; Manufacturer: Duco; Model: kokerprofiel; Type Name: kokerprofiel - 40 x 25 zwart_duco_kokerprofiel; URL: http://www.duco-professionals.eu/Wes/CDN/1/PRODUCT%20CATEGORIEN/102_Raamventilatie/COMMERCIELE%20DOCUMENTATIE/Brochure%20Raamventilatie_NL-NL.pdf; WT_I BaseKeynote: 31.2
Type - Other(Type) - Category: Generic Models; Family Name: BERSnl_31_GM_FB_kokerprofiel_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: kokerprofiel - 40 x 25 zwart_duco_kokerprofiel
Constraints - Moves With Nearby Elements: no
Dimensions - Area: 0.120524 m2; Volume: 0.000240565 m3; WT_V Lengte: 1000 mm
Other - Category: Generic Models; Family: BERSnl_31_GM_FB_kokerprofiel_duco: kokerprofiel - 40 x 25 zwart_duco_kokerprofiel; Family and Type: BERSnl_31_GM_FB_kokerprofiel_duco: kokerprofiel - 40 x 25 zwart_duco_kokerprofiel; Type: BERSnl_31_GM_FB_kokerprofiel_duco: kokerprofiel - 40 x 25 zwart_duco_kokerprofiel; Type Id: BERSnl_31_GM_FB_kokerprofiel_duco: kokerprofiel - 40 x 25 zwart_duco_kokerprofiel
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/families
