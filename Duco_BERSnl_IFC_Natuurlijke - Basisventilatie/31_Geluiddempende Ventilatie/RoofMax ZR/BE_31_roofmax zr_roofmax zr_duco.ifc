Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T15:47:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 15:47:30 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{6865967C-77F9-4F89-89BF-CAD8FD0D1AF8}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 15:47:28 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 15:47:28 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 15:47:28 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point

# IfcFlowTerminal: roofmax zr_duco_roofmax zr, BERSnl_31_AIR_FB_raamventilatie - roofmax zr_duco:roofmax zr_duco_roofmax zr:203059
In: Level 1
Type - PredefinedType: GRILLE; Classification: 31.2 (Uniformat); Material: BERSnl_n_plastic_zwart, BERSnl_a_geperforeerd, BERSnl_h4_aluminium
Type - Constraints(Type) - Default Elevation: 2500 mm
Type - Dimensions(Type) - BERSnl_C_breedte: 320 mm; BERSnl_C_diepte: 107 mm; BERSnl_C_hoogte: 335 mm
Type - Identity Data(Type) - Assembly Code: 31.2; BERSnl_C_code_artikel: 250 Uno; BERSnl_C_code_ETIM: Overstroomrooster; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 26/02/2016; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V4; BERSnl_C_description: duco_raamventilatie_roofmax zr_roofmax zr; BERSnl_C_model: RoofMax ZR; BERSnl_C_revit_versie: 2016; Manufacturer: Duco; Model: RoofMax ZR; Type Name: roofmax zr_duco_roofmax zr; URL: http://www.duco.eu/producten/product.cfm?prod=223&cat=223&pid=3-223; WT_I BaseKeynote: 31.2
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_h4_aluminium; WT_V Eindkappen_materiaal: BERSnl_n_plastic_zwart; WT_V Rooster_materiaal: BERSnl_a_geperforeerd
Type - Mechanical - Flow(Type) - WT_I Ventilatiecapaciteit 10Pa: 0.362956 m3/s; WT_I Ventilatiecapaciteit 2Pa: 0.313908 m3/s
Type - Model Properties(Type) - WT_I Geluidsniveauverschil Dne, W_in open stand: 36 dB; WT_I Kleur kopschotten: Wit, Zwart; WT_I Plaatsing: Wand - Schuin dak - Plafond - Knieschot; WT_I Waterwerendheid_in gesloten stand: 1000 Pa; WT_I Winddichtheid_in gesloten stand: 650 Pa
Type - Other(Type) - Category: Air Terminals; Family Name: BERSnl_31_AIR_FB_raamventilatie - roofmax zr_duco; WT_c1 Omschrijving: c1_Luchttoevoer
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: roofmax zr_duco_roofmax zr
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V Hoek: 30 deg
Dimensions - Area: 0.177285 m2; Size: 125 mmø; Volume: 0.0114704 m3
Identity Data - Mark: 1
Mechanical - System Classification: Supply Air
Mechanical - Flow - BE_M Drukverschil 10Pa: no; BE_M Drukverschil 2Pa: yes; BERSnl_M_debiet: 0.313908 m3/s; Flow: 0.313908 m3/s
Other - Category: Air Terminals; Family: BERSnl_31_AIR_FB_raamventilatie - roofmax zr_duco: roofmax zr_duco_roofmax zr; Family and Type: BERSnl_31_AIR_FB_raamventilatie - roofmax zr_duco: roofmax zr_duco_roofmax zr; Schedule Level: Level: Level 1; Type: BERSnl_31_AIR_FB_raamventilatie - roofmax zr_duco: roofmax zr_duco_roofmax zr; Type Id: BERSnl_31_AIR_FB_raamventilatie - roofmax zr_duco: roofmax zr_duco_roofmax zr
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
