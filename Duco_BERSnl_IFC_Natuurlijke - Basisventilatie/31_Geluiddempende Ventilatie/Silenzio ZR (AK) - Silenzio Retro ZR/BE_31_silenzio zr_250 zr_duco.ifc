Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T15:47:37
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 15:47:37 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{890B1F50-4CF5-455C-A892-5AF74042D973}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 15:47:35 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 15:47:35 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 15:47:35 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point

# IfcFlowTerminal: 250 zr_duco_silenzio zr, BERSnl_31_AIR_FB_raamventilatie - silenzio zr (ak) - silenzio retro zr_duco:250 zr_duco_silenzio zr:206725
In: Level 1
Type - PredefinedType: GRILLE; Classification: 31.2 (Uniformat); Material: BERSnl_h4_aluminium, BERSnl_n_plastic_wit, BERSnl_n_plastic_zwart, BERSnl_a_geperforeerd
Type - Constraints(Type) - Default Elevation: 2500 mm
Type - Construction(Type) - WT_V Buitenrooster_diepte: 107 mm
Type - Dimensions(Type) - BERSnl_C_breedte: 288 mm; BERSnl_C_diameter: 0 mm; BERSnl_C_hoogte: 334 mm
Type - Identity Data(Type) - Assembly Code: 31.2; BERSnl_C_code_artikel: 250 ZR; BERSnl_C_code_ETIM: Overstroomrooster; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSnl_C_code_gtin: -; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 06/02/2018; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V1; BERSnl_C_description: silenzio zr_design muurdemper_duco; BERSnl_C_model: Silenzio ZR; BERSnl_C_revit_versie: 2016; BERSnl_C_type: 250 ZR; BERSnl_C_type_comments: muurdemper; Description: silenzio zr_design muurdemper_duco; Manufacturer: Duco; Model: Silenzio ZR; Type Comments: muurdemper; Type Name: 250 zr_duco_silenzio zr; URL: http://www.duco.eu/producten/product.cfm?prod=107&cat=107&pid=3-107; WT_I BaseKeynote: 31,2
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_h4_aluminium; WT_V Binnenprofiel_materiaal: BERSnl_n_plastic_wit; WT_V Buitenprofiel_materiaal: BERSnl_h4_aluminium; WT_V Eindkappen_materiaal: BERSnl_n_plastic_zwart; WT_V Rooster_materiaal: BERSnl_a_geperforeerd
Type - Mechanical - Flow(Type) - WT_I Ventilatiecapaciteit 10Pa: 0.579749 m3/s; WT_I Ventilatiecapaciteit 2Pa: 0.582692 m3/s
Type - Model Properties(Type) - WT_I Geluidsniveauverschil Dne, W_in open stand: 39; WT_I Kleur: F1/Ral/Bi-Color; WT_I Kleur kopschotten: Wit, Zwart; WT_I Octaafbandwaarden in dB_bij 1000 Hz: 46,2; WT_I Octaafbandwaarden in dB_bij 125 Hz: 27,8; WT_I Octaafbandwaarden in dB_bij 2000 Hz: 56,8; WT_I Octaafbandwaarden in dB_bij 250 Hz: 27,5; WT_I Octaafbandwaarden in dB_bij 500 Hz: 31,9; WT_I Regelbaarheid in functie van het drukverschil: P3; WT_I U-waarde: 4.76; WT_I Wand_MAX dikte: 375 mm; WT_I Wand_MIN dikte: 270 mm; WT_I Waterdichtheid_in gesloten stand: 600 Pa; WT_I Winddichtheid_in gesloten stand: 300 Pa
Type - Other(Type) - Category: Air Terminals; Family Name: BERSnl_31_AIR_FB_raamventilatie - silenzio zr (ak) - silenzio retro zr_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: 250 zr_duco_silenzio zr
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V Wand_dikte: 300 mm
Dimensions - Area: 0.500443 m2; BERSnl_C_diepte: 476 mm; Volume: 0.0334713 m3
Identity Data - Mark: 1
Mechanical - Flow - BERSnl_M_debiet: 0.582692 m3/s; BERSnl_M_drukverschil_10Pa: no; BERSnl_M_drukverschil_2Pa: yes
Other - Category: Air Terminals; Family: BERSnl_31_AIR_FB_raamventilatie - silenzio zr (ak) - silenzio retro zr_duco: 250 zr_duco_silenzio zr; Family and Type: BERSnl_31_AIR_FB_raamventilatie - silenzio zr (ak) - silenzio retro zr_duco: 250 zr_duco_silenzio zr; Schedule Level: Level: Level 1; Type: BERSnl_31_AIR_FB_raamventilatie - silenzio zr (ak) - silenzio retro zr_duco: 250 zr_duco_silenzio zr; Type Id: BERSnl_31_AIR_FB_raamventilatie - silenzio zr (ak) - silenzio retro zr_duco: 250 zr_duco_silenzio zr
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
