Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T15:48:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 15:48:35 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{9EF49F8C-A267-4522-945F-C86F51C138D3}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 15:48:34 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 15:48:34 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 15:48:34 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowTerminal: skymax zr alto - 25 - softline - compacte plaatsing op tussenregel_duco_skymax zr, BERSnl_31_AIR_FB_raamventilatie - skymax zr_duco:skymax zr alto - 25 - softline - compacte plaatsing op tussenregel_duco_skymax zr:218287
In: Level 1
Type - PredefinedType: GRILLE; Classification: 31.2 (Uniformat); Material: BERSnl_n_plastic_zwart, BERSnl_h4_aluminium, BERSnl_a_geperforeerd
Type - Constraints(Type) - Default Elevation: 1500 mm
Type - Construction(Type) - WT_V Bediening: BERSnl_31_GM_FB_bediening ventilatierooster_duco: geen_duco_bediening ventilatierooster; WT_V Hendel: BERSnl_31_AIR_FB_hendel geluiddempend_duco: geen_duco_hendel geluiddempend; WT_V Kokerprofiel: BERSnl_31_GM_FB_kokerprofiel_duco: geen_duco_kokerprofiel
Type - Dimensions(Type) - BERSnl_C_diepte: 307 mm; BERSnl_C_hoogte: 105 mm; WT_V Roosterhoogte: 105 mm
Type - Identity Data(Type) - Assembly Code: 31.2; BERSnl_C_code_artikel: SkyMax ZR Alto\25\Softline; BERSnl_C_code_ETIM: Overstroomrooster; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSnl_C_code_gtin: -; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 26/02/2016; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V4; BERSnl_C_description: duco_raamventilatie_skymax zr_skymax zr alto - 25 - softline - compacte plaatsing op tussenregel; BERSnl_C_model: SkyMax ZR; BERSnl_C_revit_versie: 2016; BERSnl_C_type: -; Manufacturer: Duco; Model: SkyMax ZR; OmniClass Number: 3A(57.16.11); Type Name: skymax zr alto - 25 - softline - compacte plaatsing op tussenregel_duco_skymax zr; URL: http://www.duco.eu/producten/; WT_I BaseKeynote: 31.2
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_h4_aluminium; WT_V Binnenprofiel_materiaal: BERSnl_h4_aluminium; WT_V Buitenprofiel_materiaal: BERSnl_h4_aluminium; WT_V Eindkappen_materiaal: BERSnl_n_plastic_zwart; WT_V Rooster_materiaal: BERSnl_a_geperforeerd
Type - Mechanical - Flow(Type) - WT_I Ventilatiecapaciteit 10Pa: 3.2411 m3/s; WT_I Ventilatiecapaciteit 2Pa: 1.47635 m3/s
Type - Model Properties(Type) - WT_I Geluidsniveauverschil Dne, W_in open stand: 39 dB; WT_I Glas_MAX diepte: 32 mm; WT_I Glas_MIN diepte: 20 mm; WT_I Glasaftrek: 135 mm; WT_I Kleur: F1 - RAL - Bicolor; WT_I Kleur kopschotten: Wit, Zwart; WT_I Maximale lengte rooster onder garantie: 2500 mm; WT_I Maximale ton/kleplengte onder garantie: 1250 mm; WT_I Octaafbandwaarden in dB_bij 1000 Hz: 45,4; WT_I Octaafbandwaarden in dB_bij 125 Hz: 28,3; WT_I Octaafbandwaarden in dB_bij 2000 Hz: 40,9; WT_I Octaafbandwaarden in dB_bij 250 Hz: 28,9; WT_I Octaafbandwaarden in dB_bij 500 Hz: 33,9; WT_I Regelbaarheid in functie van het drukverschil: P4; WT_I Splitsing vanaf lengte: 1000 mm; WT_I U-waarde: 2.58; WT_I Waterwerendheid_in gesloten stand: 1050 Pa; WT_I Winddichtheid_in gesloten stand: 600 Pa; WT_I X_maat MAX: 287 mm; WT_I X_maat MIN: 187 mm
Type - Other(Type) - Category: Air Terminals; Family Name: BERSnl_31_AIR_FB_raamventilatie - skymax zr_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: skymax zr alto - 25 - softline - compacte plaatsing op tussenregel_duco_skymax zr
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V Glas_diepte: 20 mm; WT_V Hendeloverbrenging & Stangclip: BERSnl_31_AIR_FB_hendeloverbrenging & stangclip_duco: geen_duco_hendeloverbrenging & stangclip; WT_V Losse Bochten: BERSnl_31_AIR_FB_losse bocht_duco: geen_duco_losse bocht; WT_V X_maat: 287 mm
Dimensions - Area: 0.444235 m2; BERSnl_C_lengte: 1000 mm; Volume: 0.032235 m3
Identity Data - Mark: 71
Mechanical - Flow - BE_M Drukverschil 10Pa: yes; BE_M Drukverschil 2Pa: yes; BERSnl_M_debiet: 1.46749 m3/s
Model Properties - WT_I Onder garantie: Ja; WT_I Splitsing_aantal: 1
Other - Category: Air Terminals; Family: BERSnl_31_AIR_FB_raamventilatie - skymax zr_duco: skymax zr alto - 25 - softline - compacte plaatsing op tussenregel_duco_skymax zr; Family and Type: BERSnl_31_AIR_FB_raamventilatie - skymax zr_duco: skymax zr alto - 25 - softline - compacte plaatsing op tussenregel_duco_skymax zr; Schedule Level: Level: Level 1; Type: BERSnl_31_AIR_FB_raamventilatie - skymax zr_duco: skymax zr alto - 25 - softline - compacte plaatsing op tussenregel_duco_skymax zr; Type Id: BERSnl_31_AIR_FB_raamventilatie - skymax zr_duco: skymax zr alto - 25 - softline - compacte plaatsing op tussenregel_duco_skymax zr
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
