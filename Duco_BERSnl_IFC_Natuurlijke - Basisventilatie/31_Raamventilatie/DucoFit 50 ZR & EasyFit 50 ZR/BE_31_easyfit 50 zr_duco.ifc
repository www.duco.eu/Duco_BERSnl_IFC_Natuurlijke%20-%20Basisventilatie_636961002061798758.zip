Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T15:27:25
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 15:27:25 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{7DD2B8DE-FF9B-474B-B31B-B6F9D4F5169C}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 15:27:24 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 15:27:25 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 15:27:25 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowTerminal: easyfit 50 zr_duco, BERSnl_31_AIR_FB_raamventilatie - ducofit 50 zr - easyfit 50 zr_duco:easyfit 50 zr_duco:213222
In: Level 1
Type - PredefinedType: GRILLE; Classification: 31.2 (Uniformat); Material: BERSnl_n_plastic_zwart, BERSnl_h4_aluminium geperforeerd, BERSnl_h4_aluminium
Type - Constraints(Type) - Default Elevation: 1500 mm
Type - Construction(Type) - WT_V Bediening: BERSnl_31_GM_FB_bediening ventilatierooster_duco: geen_gen; WT_V Hendel: BERSnl_31_AIR_FB_hendel_duco: hendel 15_duco_wit
Type - Dimensions(Type) - BERSnl_C_diepte: 81 mm; BERSnl_C_hoogte: 88 mm; WT_I Inbouwhoogte: 55 mm; WT_V Rooster_hoogte: 50 mm
Type - Identity Data(Type) - Assembly Code: 31.2; BERSnl_C_code_artikel: EasyFit 50 ZR; BERSnl_C_code_ETIM: Overstroomrooster; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSnl_C_code_gtin: -; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 06/02/2018; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V1; BERSnl_C_description: EasyFit 50 ZR_raamventilatie_duco; BERSnl_C_model: EasyFit 50 ZR; BERSnl_C_revit_versie: 2016; BERSnl_C_type: EasyFit 50 ZR; BERSnl_C_type_comments: raamventilatie; Description: EasyFit 50 ZR_raamventilatie_duco; Manufacturer: Duco; Model: EasyFit 50 ZR; OmniClass Number: 3A(57.16.11); Type Comments: raamventilatie; Type Name: easyfit 50 zr_duco; URL: http://www.duco.eu/producten/product.cfm?prod=169&pid=3-1&cat=1; WT_I BaseKeynote: 31.2
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_h4_aluminium; WT_V Binnenprofiel_materiaal: BERSnl_h4_aluminium; WT_V Buitenprofiel_materiaal: BERSnl_h4_aluminium; WT_V Eindkappen_materiaal: BERSnl_n_plastic_zwart; WT_V Rooster_materiaal: BERSnl_h4_aluminium geperforeerd
Type - Mechanical - Flow(Type) - WT_I Ventilatiecapaciteit 10Pa: 0.613102 m3/s; WT_I Ventilatiecapaciteit 2Pa: 0.586616 m3/s
Type - Model Properties(Type) - WT_I Geluidsniveauverschil Dne, W_in open stand: 28,0 dB; WT_I Kleur: F1 - RAL; WT_I Kleur kopschotten: Wit, Zwart; WT_I Maximale lengte rooster onder garantie: 3070 mm; WT_I Maximale ton/kleplengte onder garantie: 1500 mm; WT_I Regelbaarheid in functie van het drukverschil: P3; WT_I Splitsing vanaf lengte: 1500 mm; WT_I U-waarde: 3.11; WT_I Waterdichtheid_in gesloten stand: 1215 Pa; WT_I Winddichtheid_in gesloten stand: 450 Pa
Type - Other(Type) - Category: Air Terminals; Family Name: BERSnl_31_AIR_FB_raamventilatie - ducofit 50 zr - easyfit 50 zr_duco
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: easyfit 50 zr_duco
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V Buitenprofiel: no; WT_V Hendeloverbrenging & Stangclip: BERSnl_31_AIR_FB_hendeloverbrenging & stangclip_duco: geen_gen; WT_V Losse Bochten: BERSnl_31_AIR_FB_losse bocht_duco: geen_gen; WT_V Raam_diepte: 80 mm
Dimensions - Area: 0.279338 m2; BERSnl_C_lengte: 1000 mm; Volume: 0.00503658 m3
Identity Data - Mark: 3
Mechanical - Flow - BERSnl_M_debiet: 0.551419 m3/s; BERSnl_M_drukverschil_10Pa: no; BERSnl_M_drukverschil_2Pa: yes
Model Properties - WT_I Onder garantie: Ja; WT_I Raam_MAX dipte: 184 mm; WT_I Raam_MIN diepte: 50 mm; WT_I Splitsing_aantal: 0
Other - Category: Air Terminals; Family: BERSnl_31_AIR_FB_raamventilatie - ducofit 50 zr - easyfit 50 zr_duco: easyfit 50 zr_duco; Family and Type: BERSnl_31_AIR_FB_raamventilatie - ducofit 50 zr - easyfit 50 zr_duco: easyfit 50 zr_duco; Schedule Level: Level: Level 1; Type: BERSnl_31_AIR_FB_raamventilatie - ducofit 50 zr - easyfit 50 zr_duco: easyfit 50 zr_duco; Type Id: BERSnl_31_AIR_FB_raamventilatie - ducofit 50 zr - easyfit 50 zr_duco: easyfit 50 zr_duco
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/duco
