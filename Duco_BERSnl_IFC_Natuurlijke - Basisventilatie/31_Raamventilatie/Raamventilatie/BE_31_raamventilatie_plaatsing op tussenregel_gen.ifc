Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T16:01:55
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 16:01:55 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{0CAB8C69-0447-4FBE-AB6A-3BAF3442BD5C}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 16:01:53 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 16:01:53 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 16:01:53 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point

# IfcFlowTerminal: plaatsing op tussenregel_gen_raamventilatie, BERSnl_31_AIR_FB_raamventilatie_gen:plaatsing op tussenregel_gen_raamventilatie:199427
In: Level 1
Type - PredefinedType: GRILLE; Classification: 31.2 (Uniformat); Material: BERSnl_h4_aluminium
Type - Constraints(Type) - Default Elevation: 1500 mm
Type - Construction(Type) - WT_V Binnen rooster_diepte: 40 mm; WT_V Buiten rooster_diepte: 50 mm; WT_V Eindkappen_lengte: 35 mm; WT_V Plaatsing op glas: no; WT_V Plaatsing op het raam: no; WT_V Plaatsing op tussenregel: yes; WT_V Plaatsing op tussenregel_compacte: no; WT_V Raam of glas_diepte: 25 mm; WT_V Uitsnijding_hoogte: 90 mm; WT_V Uitsteek bovenkant_hoogte: 15 mm; WT_V Uitsteek onderkant_hoogte: 20 mm
Type - Dimensions(Type) - BERSnl_C_diepte: 115 mm; BERSnl_C_hoogte: 90 mm; WT_V Roosterhoogte: 0 mm
Type - Identity Data(Type) - Assembly Code: 31.2; BERSnl_C_code_ETIM: Overstroomrooster; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 26/02/2016; BERSnl_C_content_provider: ThorbiQ nv; BERSnl_C_content_versie: V5; BERSnl_C_description: gen_raamventilatie_plaatsing op tussenregel; BERSnl_C_model: -; BERSnl_C_revit_versie: 2016; Manufacturer: gen; Model: -; OmniClass Number: 3A(57.16.11); Type Name: plaatsing op tussenregel_gen_raamventilatie; WT_I BaseKeynote: 31.2
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_h4_aluminium; WT_V Eindkappen_materiaal: BERSnl_n_plastic_zwart
Type - Mechanical - Flow(Type) - WT_I Ventilatiecapaciteit 10Pa: 0.51991 m3/s; WT_I Ventilatiecapaciteit 2Pa: 0.51991 m3/s
Type - Other(Type) - Category: Air Terminals; Family Name: BERSnl_31_AIR_FB_raamventilatie_gen
Pset_ManufacturerTypeInformation - Manufacturer: gen
Pset_DistributionFlowElementCommon - Reference: plaatsing op tussenregel_gen_raamventilatie
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Dimensions - Area: 0.44505 m2; BERSnl_C_lengte: 1200 mm; Volume: 0.01134 m3
Identity Data - Mark: 3
Mechanical - Flow - BERSnl_M_debiet: 0.587499 m3/s
Other - Category: Air Terminals; Family: BERSnl_31_AIR_FB_raamventilatie_gen: plaatsing op tussenregel_gen_raamventilatie; Family and Type: BERSnl_31_AIR_FB_raamventilatie_gen: plaatsing op tussenregel_gen_raamventilatie; Schedule Level: Level: Level 1; Type: BERSnl_31_AIR_FB_raamventilatie_gen: plaatsing op tussenregel_gen_raamventilatie; Type Id: BERSnl_31_AIR_FB_raamventilatie_gen: plaatsing op tussenregel_gen_raamventilatie
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/families
