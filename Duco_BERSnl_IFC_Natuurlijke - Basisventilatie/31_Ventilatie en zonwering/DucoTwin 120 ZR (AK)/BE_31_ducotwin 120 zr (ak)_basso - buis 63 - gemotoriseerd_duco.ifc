Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
File name: Project Number
Time: 2019-01-02T15:41:14
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20161004_0715(x64) - Exporter 16.6.0.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Jan 02 15:41:14 2019 * Host: DESKTOP-OVRUSE6 * Database: C:\Users\LINIA_2\AppData\Local\Temp\{8A420261-48D1-4006-A5E1-112F5797614E}\ifc * Database version: 5507 * Database creation date: Wed Jan 02 15:41:11 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Jan 02 15:41:12 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Jan 02 15:41:12 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: ## Street City, State Zip; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Center; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcFlowTerminal: basso - buis 63 - gemotoriseerd_duco_ducotwin 120 zr (ak), BERSnl_31_AIR_FB_raamventilatie - ducotwin 120 zr (ak)_duco:basso - buis 63 - gemotoriseerd_duco_ducotwin 120 zr (ak):209241
In: Level 1
Type - PredefinedType: GRILLE; Classification: 31.2 (Uniformat); Material: BERSnl_h4_aluminium, BERSnl_n_plastic_zwart, BERSnl_a_geperforeerd, Linen, White
Type - Constraints(Type) - Default Elevation: 1500 mm
Type - Construction(Type) - WT_V Buiten rooster_diepte: 69 mm; WT_V Geleiders_type: GEO_DucoTwin 120_geleiders: geleider_duco_ducotwin 120
Type - Dimensions(Type) - BERSnl_C_diepte: 227 mm; BERSnl_C_hoogte: 178.5 mm; WT_V Roosterhoogte: 120 mm
Type - Identity Data(Type) - Assembly Code: 31.2; BERSnl_C_code_artikel: Basso/Buis 63/Gemotoriseerd; BERSnl_C_code_ETIM: Overstroomrooster; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSnl_C_code_gtin: -; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 26/02/2016; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V4; BERSnl_C_description: duco_raamventilatie_ducotwin 120 zr (ak)_basso - buis 63 - gemotoriseerd; BERSnl_C_model: DucoTwin 120; BERSnl_C_revit_versie: 2016; BERSnl_C_type: -; Manufacturer: Duco; Model: DucoTwin 120; OmniClass Number: 3A(57.16.11); Type Name: basso - buis 63 - gemotoriseerd_duco_ducotwin 120 zr (ak); URL: http://www.duco.eu/producten/product.cfm?prod=230&pid=3-28&cat=28; WT_I BaseKeynote: 31.2
Type - Materials and Finishes(Type) - BERSnl_C_materiaal: BERSnl_h4_aluminium; WT_V Binnenprofiel_materiaal: BERSnl_h4_aluminium; WT_V Buitenprofiel_materiaal: BERSnl_h4_aluminium; WT_V Eindkappen_materiaal: BERSnl_n_plastic_zwart; WT_V Rooster_materiaal: BERSnl_a_geperforeerd; WT_V Zonwering_materiaal: Linen, White
Type - Mechanical - Flow(Type) - WT_I Ventilatiecapaciteit 10Pa: 1.01628 m3/s; WT_I Ventilatiecapaciteit 2Pa: 0.84559 m3/s
Type - Model Properties(Type) - WT_I Buis 50: no; WT_I Buis 63: yes; WT_I Buis 78: no; WT_I Cap_zonwering op uitvalarm: no; WT_I Geluidsniveauverschil Dne, W_in open stand: 33 dB; WT_I Kleur: F1 - RAL - Bicolor; WT_I Maximale lengte rooster onder garantie: 3400 mm; WT_I Maximale ton/kleplengte onder garantie: 2000 mm; WT_I Raam_MAX diepte: 115 mm; WT_I Waterwerendheid_in gesloten stand: 1250 Pa; WT_I Winddichtheid_in gesloten stand: 450 Pa; WT_I Zonwering_gemotoriseerd: yes; WT_I Zonwering_manueel: no; WT_I Zonwering_maximale breedte: 3400 mm; WT_I Zonwering_maximale hoogte: 3000 mm; WT_I Zonwering_oppervlakte: 7.5 m2
Type - Other(Type) - Category: Air Terminals; Family Name: BERSnl_31_AIR_FB_raamventilatie - ducotwin 120 zr (ak)_duco
Type - Text(Type) - WT_I Revit handleiding: http://www.witas.be/niko
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: basso - buis 63 - gemotoriseerd_duco_ducotwin 120 zr (ak)
Constraints - Elevation: 0 mm; Host: Level : Level 1; Level: Level: Level 1
Construction - WT_V Raam_diepte: 80 mm; WT_V Ventilatierooster_bediening: BERSnl_31_GM_FB_bediening ventilatierooster_duco: hendel_kort_duco_bediening ventilatierooster; WT_V Zijgeleider_hoogte: 1800 mm; WT_V Zonwering_opening lengte: 500 mm; WT_V Zonweringdoek_bediening: BERSnl_31_GM_FB_bediening zonweringdoek_duco: buismotor met knopbediening_duco_bediening zonweringdoek
Dimensions - Area: 1.2722 m2; BERSnl_C_lengte: 1000 mm; Volume: 0.0366523 m3
Identity Data - Mark: 125
Mechanical - Flow - BE_M Drukverschil 10Pa: no; BE_M Drukverschil 2Pa: yes; BERSnl_M_debiet: 0.786399 m3/s
Model Properties - WT_I Onder garantie: Ja
Other - Category: Air Terminals; Family: BERSnl_31_AIR_FB_raamventilatie - ducotwin 120 zr (ak)_duco: basso - buis 63 - gemotoriseerd_duco_ducotwin 120 zr (ak); Family and Type: BERSnl_31_AIR_FB_raamventilatie - ducotwin 120 zr (ak)_duco: basso - buis 63 - gemotoriseerd_duco_ducotwin 120 zr (ak); Schedule Level: Level: Level 1; Type: BERSnl_31_AIR_FB_raamventilatie - ducotwin 120 zr (ak)_duco: basso - buis 63 - gemotoriseerd_duco_ducotwin 120 zr (ak); Type Id: BERSnl_31_AIR_FB_raamventilatie - ducotwin 120 zr (ak)_duco: basso - buis 63 - gemotoriseerd_duco_ducotwin 120 zr (ak)
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/families

# IfcFlowTerminal: geleider_duco_ducotwin 120 (2)
In: Level 1
Type - PredefinedType: GRILLE; Classification: 31.2 (Uniformat); Material: BERSnl_h4_aluminium
Type - Constraints(Type) - Default Elevation: 1219.2 mm
Type - Construction(Type) - WT_V Fix: no; WT_V Standaard: yes
Type - Identity Data(Type) - Assembly Code: 31.2; BERSnl_C_code_ETIM: Overstroomrooster; BERSnl_C_code_ETIM_url: http://prod.etim-international.com/Class/Details?classId=EC010230&classVersion=5; BERSnl_C_content_creator: ThorbiQ nv; BERSnl_C_content_datum_gewijzigd: 23/03/2018; BERSnl_C_content_datum_uitgifte: 26/02/2016; BERSnl_C_content_provider: Duco; BERSnl_C_content_versie: V4; BERSnl_C_description: duco_raamventilatie_ducotwin 120_fix; BERSnl_C_revit_versie: 2016; Manufacturer: Duco; Type Name: geleider_duco_ducotwin 120; URL: http://www.duco.eu/producten/; WT_I BaseKeynote: 57.10.90.1
Type - Other(Type) - Category: Air Terminals; Family Name: GEO_DucoTwin 120_geleiders
Pset_ManufacturerTypeInformation - Manufacturer: Duco
Pset_DistributionFlowElementCommon - Reference: geleider_duco_ducotwin 120
Constraints - Moves With Nearby Elements: no
Dimensions - Area: 1.05092 m2; Volume: 0.000714961 m3; WT_V Lengte: 1800 mm
Materials and Finishes - BERSnl_C_materiaal: BERSnl_h4_aluminium
Other - Category: Air Terminals; Family: GEO_DucoTwin 120_geleiders: geleider_duco_ducotwin 120; Family and Type: GEO_DucoTwin 120_geleiders: geleider_duco_ducotwin 120; Type: GEO_DucoTwin 120_geleiders: geleider_duco_ducotwin 120; Type Id: GEO_DucoTwin 120_geleiders: geleider_duco_ducotwin 120
Phasing - Phase Created: New Construction
Text - BERSnl_C_content_handleiding: http://www.witas.be/nl/families
Name (GEO_DucoTwin 120_geleiders:geleider_duco_ducotwin 120:...) | Mark
209243 | 127
209244 | 128
